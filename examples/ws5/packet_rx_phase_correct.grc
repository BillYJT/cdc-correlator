options:
  parameters:
    category: Packet Operators
    generate_options: hb
    id: packet_rx_phase_correct
    output_language: python
  states: {}

blocks:
- name: mark_delay
  id: variable
  parameters:
    value: mark_delays[sps]
  states: {}
- name: mark_delays
  id: variable
  parameters:
    comment: |-
      Tag Marking Delay for 
      Corr Est block, indexed
      by sps.

      Found empirically.
    value: '[0, 0, 34, 56, 87, 119]'
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: rxmod
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: preamble_select[int(1.0/hdr_dec.rate())]
  states: {}
- name: preamble_dummy
  id: variable
  parameters:
    comment: |-
      use when header
      FEC is Dummy
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: preamble_rep
  id: variable
  parameters:
    comment: |-
      use when header
      FEC is Repetition (x3)
    value: '[0xe3, 0x8f, 0xc0, 0xfc, 0x7f, 0xc7, 0xe3, 0x81, 0xc0, 0xff, 0x80, 0x38, 0xff, 0xf0, 0x38, 0xe0, 0x0f, 0xc0, 0x03, 0x80, 0x00, 0xff, 0xff, 0xc0]'
  states: {}
- name: preamble_select
  id: variable
  parameters:
    value: '{1: preamble_dummy, 3: preamble_rep}'
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(hdr_const, False, sps, True, eb, False, False)
  states: {}
- name: blocks_multiply_by_tag_value_cc_0
  id: blocks_multiply_by_tag_value_cc
  parameters:
    tagname: '"amp_est"'
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: pld_const.bits_per_symbol()
    lengthtagname: '"payload symbols"'
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: '"payload symbols"'
    type: float
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: pld_const
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: hdr_const
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: mark_delay
    sps: sps
    symbols: modulated_sync_word
    threshold: '0.999'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: hdr_const.arity()
    w: 6.28/200.0
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: pld_const.arity()
    w: 6.28/200.0
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: (hdr_format.header_nbits() * int(1.0/hdr_dec.rate())) //  hdr_const.bits_per_symbol()
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload symbols"'
    output_symbols: 'True'
    samp_rate: '1'
    special_tags: '""'
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"time_est"'
    type: complex
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/400.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: psf_taps
    type: ccf
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: eb
  id: parameter
  parameters:
    label: Filter Rolloff
    type: eng_float
    value: '0.35'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import cmath


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Phase Recovery by phase_est',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              #self.example_param = example_param
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def work(self, input_items, output_items):
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              phase_offset = 0
              index = 1
              for tag in tags:
              	if pmt.to_python(tag.key) == "phase_est":
              		phase_offset = pmt.to_python(tag.value)
              		
              		#print("obtained phase est", phase_offset)
              	else:
              		self.add_item_tag(0,tag.offset,
              				  tag.key,
              				  tag.value)
              		#index = index+1
              		
              output_items[0][:] = input_items[0]*cmath.rect(1,-phase_offset)
              return len(output_items[0])
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: pld_dec
    mtu: 1500*8
    packed: 'True'
    rev_pack: 'False'
  states: {}
- name: fec_generic_decoder_0
  id: fec_generic_decoder
  parameters:
    decoder: hdr_dec
    itype: float
    otype: byte
  states: {}
- name: hdr_const
  id: parameter
  parameters:
    label: Header constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: hdr_dec
  id: parameter
  parameters:
    label: Header FEC Decoder
    value: ' fec.dummy_decoder.make(8000)'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pkt out
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: precrc
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: hdr_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: pld_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_3_0
  id: pad_sink
  parameters:
    label: pld_phs
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_5
  id: pad_sink
  parameters:
    label: timing
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_7
  id: pad_sink
  parameters:
    label: corr est
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_7_0
  id: pad_sink
  parameters:
    label: post_phase_recovery
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pld_const
  id: parameter
  parameters:
    label: Payload constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: pld_dec
  id: parameter
  parameters:
    label: Payload FEC Decoder
    value: ' fec.dummy_decoder.make(8000)'
  states: {}
- name: psf_taps
  id: parameter
  parameters:
    label: Pulse Shape Filter
    value: '[0,]'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: eng_float
    value: '2'
  states: {}

connections:
- [blocks_multiply_by_tag_value_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, fec_async_decoder_0, in]
- [digital_constellation_soft_decoder_cf_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', fec_generic_decoder_0, '0']
- [digital_corr_est_cc_0, '0', blocks_multiply_by_tag_value_cc_0, '0']
- [digital_corr_est_cc_0, '1', pad_sink_7, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', pad_sink_3_0, '0']
- [digital_crc32_async_bb_0, out, pad_sink_0, in]
- [digital_header_payload_demux_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_header_payload_demux_0, '0', pad_sink_2, '0']
- [digital_header_payload_demux_0, '1', digital_costas_loop_cc_0_0_0, '0']
- [digital_header_payload_demux_0, '1', pad_sink_3, '0']
- [digital_pfb_clock_sync_xxx_0, '0', epy_block_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', pad_sink_5, '0']
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [epy_block_0, '0', digital_header_payload_demux_0, '0']
- [epy_block_0, '0', pad_sink_7_0, '0']
- [fec_async_decoder_0, out, digital_crc32_async_bb_0, in]
- [fec_async_decoder_0, out, pad_sink_1, in]
- [fec_generic_decoder_0, '0', digital_protocol_parser_b_0, '0']
- [pad_source_0, '0', digital_corr_est_cc_0, '0']

metadata:
  file_format: 1
