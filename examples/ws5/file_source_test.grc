options:
  parameters:
    generate_options: qt_gui
    id: file_source_test
    output_language: python
    title: File Source Test
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD_0
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {state: disabled}
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '200'
    value: '1'
  states: {}
- name: corr_threshold
  id: variable_qtgui_range
  parameters:
    label: Correlator Threshold
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.005'
    stop: '0.999'
    value: '0.999'
  states: {}
- name: damp_factor
  id: variable_qtgui_range
  parameters:
    label: Damping Factor
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: dec
  id: variable_repetition_decoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {state: disabled}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_0
  id: variable_dummy_decoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: dec_hdr
  id: variable_dummy_decoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
  states: {state: disabled}
- name: dec_hdr
  id: variable_repetition_decoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.22'
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {state: disabled}
- name: enc_1
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: enc_hdr
  id: variable_repetition_encoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
    rep: rep
  states: {}
- name: enc_hdr_0
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Freq. Offset
    orient: Qt.Horizontal
    start: '-0.5'
    step: '0.0001'
    stop: '0.5'
    value: '0'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: digital.packet_utils.default_access_code
    bps: '1'
    threshold: '3'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    label: Loop Bandwidth
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: '1.57'
    value: '0.125'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Noise Amp
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0.0'
  states: {state: disabled}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 500e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '75'
    value: '50'
  states: {}
- name: rx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*sps
    sym_rate: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    label: TED Gain
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.05'
    stop: '5'
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Time Offset
    orient: Qt.Horizontal
    start: '0.99'
    step: '0.00001'
    stop: '1.01'
    value: '1.0'
  states: {}
- name: tx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 5*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/cdc/code/gr-correlator/examples/ws5/test_signal
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: hdr_out
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    name: pld_out
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0_0_1
  id: blocks_tag_debug
  parameters:
    name: corr_est_tag
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: rf_freq
    gain0: '50'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: packet_rx_single_costa_0
  id: packet_rx_single_costa
  parameters:
    damp_factor: damp_factor
    eb: eb
    hdr_const: Const_HDR
    hdr_dec: dec_hdr
    hdr_format: hdr_format
    loop_bw: loop_bw
    pld_const: Const_PLD
    pld_dec: dec
    psf_taps: rx_rrc_taps
    sps: sps
    ted_gain: ted_gain
    threshold: corr_threshold
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Scaled Symbol"'
    size: '1024'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab1@2
    legend: 'False'
    size: '800'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"synced symbol"'
    size: '1024'
    tr_tag: '"corr_est"'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"header"'
    size: '1024'
    tr_tag: '"corr_est"'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"pay load"'
    size: '1024'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab1@1
    legend: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: |-
      Plot correlation result of received
      waveform with modulated training
      sequence. Trigger set to align plot
      with "corr_est" stream tag added 
      by Correlation Estimator.
    name: '"Correlation Result"'
    size: '1024'
    srate: '1'
    tr_level: '10'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: float
    ymax: '16000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: |-
      Plot correlation result of received
      waveform with modulated training
      sequence. Trigger set to align plot
      with "corr_est" stream tag added 
      by Correlation Estimator.
    name: '"Scaled Signal"'
    size: '1024'
    srate: '1'
    tr_level: '10'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
    ymax: '16000'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Plot correlation result of received
      waveform with modulated training
      sequence. Trigger set to align plot
      with "corr_est" stream tag added 
      by Correlation Estimator.
    name: '"ACG''d RX signal"'
    size: '1024'
    srate: '1'
    tr_level: '0.5'
    tr_tag: '"corr_est"'
    type: complex
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: ''
    label2: ''
    legend: 'False'
    size: '1250'
    srate: '1'
    tr_delay: '50'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
    ylabel: Correlation
    ymax: '150'
    ymin: '-150'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab1@0
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    size: '125'
    srate: '1'
    style1: '3'
    tr_delay: '25'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"payload symbols"'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"synced symbol"'
    size: '1024'
    srate: '1'
    tr_level: '10'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
  states: {state: disabled}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,1,1,1
    label0: Time
    label1: Freq.
    label2: Const.
    num_tabs: '3'
  states: {state: disabled}
- name: tab1
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,2,1,1
    label0: Time
    label1: Freq.
    label2: Const.
    num_tabs: '3'
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', packet_rx_single_costa_0, '0']
- [blocks_throttle_0, '0', analog_agc_xx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [packet_rx_single_costa_0, '0', blocks_tag_debug_0, '0']
- [packet_rx_single_costa_0, '0', qtgui_const_sink_x_1_0, '0']
- [packet_rx_single_costa_0, '1', blocks_tag_debug_0_0, '0']
- [packet_rx_single_costa_0, '1', qtgui_const_sink_x_1_0_0, '0']
- [packet_rx_single_costa_0, '2', blocks_complex_to_mag_squared_0, '0']
- [packet_rx_single_costa_0, '3', blocks_tag_debug_0_0_0, '0']
- [packet_rx_single_costa_0, '3', qtgui_const_sink_x_1, '0']
- [packet_rx_single_costa_0, '4', qtgui_const_sink_x_0, '0']
- [packet_rx_single_costa_0, '4', qtgui_time_sink_x_0_0_0, '0']
- [packet_rx_single_costa_0, pkt out, blocks_message_debug_0_0_0, print_pdu]

metadata:
  file_format: 1
