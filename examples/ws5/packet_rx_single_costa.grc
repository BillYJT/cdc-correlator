options:
  parameters:
    category: Packet Operators
    generate_options: hb
    id: packet_rx_single_costa
    output_language: python
  states: {}

blocks:
- name: mark_delay
  id: variable
  parameters:
    value: mark_delays[sps]
  states: {}
- name: mark_delays
  id: variable
  parameters:
    comment: |-
      Tag Marking Delay for 
      Corr Est block, indexed
      by sps.

      Found empirically.
    value: '[0, 0, 34, 56, 87, 119]'
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: rxmod
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: preamble_select[int(1.0/hdr_dec.rate())]
  states: {}
- name: preamble_dummy
  id: variable
  parameters:
    comment: |-
      use when header
      FEC is Dummy
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: preamble_rep
  id: variable
  parameters:
    comment: |-
      use when header
      FEC is Repetition (x3)
    value: '[0xe3, 0x8f, 0xc0, 0xfc, 0x7f, 0xc7, 0xe3, 0x81, 0xc0, 0xff, 0x80, 0x38, 0xff, 0xf0, 0x38, 0xe0, 0x0f, 0xc0, 0x03, 0x80, 0x00, 0xff, 0xff, 0xc0]'
  states: {}
- name: preamble_select
  id: variable
  parameters:
    value: '{1: preamble_dummy, 3: preamble_rep}'
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(hdr_const, False, sps, True, eb, False, False)
  states: {}
- name: blocks_multiply_by_tag_value_cc_0
  id: blocks_multiply_by_tag_value_cc
  parameters:
    tagname: '"amp_est"'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: pld_const.bits_per_symbol()
    lengthtagname: '"payload symbols"'
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: '"payload symbols"'
    type: float
  states: {}
- name: correlator_corr_est_0
  id: correlator_corr_est
  parameters:
    mark_delay: mark_delay
    sps: sps
    symbols: modulated_sync_word
    threshold: threshold
    threshold_method: correlator.THRESHOLD_DYNAMIC
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: pld_const
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: hdr_const
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: mark_delay
    sps: sps
    symbols: modulated_sync_word
    threshold: threshold
    threshold_method: digital.THRESHOLD_DYNAMIC
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: hdr_const.arity()
    w: 6.28/200.0
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: (hdr_format.header_nbits() * int(1.0/hdr_dec.rate())) //  hdr_const.bits_per_symbol()
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload symbols"'
    output_symbols: 'True'
    samp_rate: '1'
    special_tags: '""'
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"time_est"'
    type: complex
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/400.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: psf_taps
    type: ccf
  states: {state: disabled}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 6.28/400
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: psf_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: eb
  id: parameter
  parameters:
    label: Filter Rolloff
    type: eng_float
    value: '0.35'
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: pld_dec
    mtu: 1500*8
    packed: 'True'
    rev_pack: 'False'
  states: {}
- name: fec_generic_decoder_0
  id: fec_generic_decoder
  parameters:
    decoder: hdr_dec
    itype: float
    otype: byte
  states: {}
- name: hdr_const
  id: parameter
  parameters:
    label: Header constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: hdr_dec
  id: parameter
  parameters:
    label: Header FEC Decoder
    value: ' fec.dummy_decoder.make(8000)'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pkt out
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: precrc
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: hdr_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: pld_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_3_0
  id: pad_sink
  parameters:
    label: pld_phs
    optional: 'True'
    type: complex
  states: {state: disabled}
- name: pad_sink_5
  id: pad_sink
  parameters:
    label: timing
    optional: 'True'
    type: complex
  states: {state: disabled}
- name: pad_sink_7
  id: pad_sink
  parameters:
    label: corr est
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_7_0
  id: pad_sink
  parameters:
    label: sync error
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_7_1
  id: pad_sink
  parameters:
    label: synced symbol
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pld_const
  id: parameter
  parameters:
    label: Payload constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: pld_dec
  id: parameter
  parameters:
    label: Payload FEC Decoder
    value: ' fec.dummy_decoder.make(8000)'
  states: {}
- name: psf_taps
  id: parameter
  parameters:
    label: Pulse Shape Filter
    value: '[0,]'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: eng_float
    value: '2'
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold
    type: eng_float
    value: '0.999'
  states: {}

connections:
- [blocks_multiply_by_tag_value_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_multiply_by_tag_value_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, fec_async_decoder_0, in]
- [correlator_corr_est_0, '0', blocks_multiply_by_tag_value_cc_0, '0']
- [correlator_corr_est_0, '1', pad_sink_7, '0']
- [digital_constellation_soft_decoder_cf_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', fec_generic_decoder_0, '0']
- [digital_corr_est_cc_0, '0', blocks_multiply_by_tag_value_cc_0, '0']
- [digital_corr_est_cc_0, '1', pad_sink_7, '0']
- [digital_costas_loop_cc_0, '0', blocks_null_sink_0, '0']
- [digital_costas_loop_cc_0, '0', digital_header_payload_demux_0, '0']
- [digital_crc32_async_bb_0, out, pad_sink_0, in]
- [digital_header_payload_demux_0, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [digital_header_payload_demux_0, '0', pad_sink_2, '0']
- [digital_header_payload_demux_0, '1', digital_constellation_soft_decoder_cf_0, '0']
- [digital_header_payload_demux_0, '1', pad_sink_3, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', pad_sink_5, '0']
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', pad_sink_7_1, '0']
- [digital_symbol_sync_xx_0, '1', pad_sink_7_0, '0']
- [fec_async_decoder_0, out, digital_crc32_async_bb_0, in]
- [fec_async_decoder_0, out, pad_sink_1, in]
- [fec_generic_decoder_0, '0', digital_protocol_parser_b_0, '0']
- [pad_source_0, '0', correlator_corr_est_0, '0']
- [pad_source_0, '0', digital_corr_est_cc_0, '0']

metadata:
  file_format: 1
