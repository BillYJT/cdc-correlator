options:
  parameters:
    author: cdc
    generate_options: qt_gui
    id: message_printer
    output_language: python
    title: Message Printer
  states: {}

blocks:
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='Print Message',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        \n        #self.message_port_register_out(pmt.intern('msg_out'))\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n\n    def handle_msg(self, msg):\n    \tprint(msg)\n\n"
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: value
    label: Type a message to print
    type: string
  states: {}

connections:
- [qtgui_edit_box_msg_0, msg, epy_block_0, msg_in]

metadata:
  file_format: 1
